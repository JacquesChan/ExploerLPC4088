# Keil uVision project LED.uvprojx, settings and files
target LED (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: LPC4088FBD208 NXP
  pack: Keil.LPC4000_DFP.2.1.0
  cpu: IRAM(0x10000000,0x10000) IRAM2(0x20000000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: CORE_M4
  c include: ..\Hardware;..\System;..\Drivers\Include
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x10000
  memory RVCT10: RAM 0x20000000 size 0x8000
  group User
    ./: main.c
  group Driver
    ../Drivers/Source/: gpio_17xx_40xx.c gpioint_17xx_40xx.c clock_17xx_40xx.c
  group System
    ../System/: delay.c
  group Hardware
    ../Hardware/: led.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.1
